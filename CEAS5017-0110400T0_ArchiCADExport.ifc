Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2021-05-11T10:33:56
Written by: The EXPRESS Data Manager Version 5.02.0100.09 : 26 Sep 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Default UI

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcDistributionPort (2)
Pset_DistributionPortPipe - ConnectionType: WELDED
MEPPortPipe - ProfileShape: ROUND
Name | FlowDirection | PortNumber | OuterDiameter (mm) = ConnectorDiameter (mm) = NominalWidth (mm) = NominalHeight (mm)
 | SINK | 1 | 15
 | SOURCE | 2 | 110

# IfcEnergyConversionDevice: Aerozen G2 Smart Toilet, CEAS5017-0110400T0:Aerozen G2 Smart Toilet:3843
In: Level 1
Pset_ManufacturerTypeInformation - ModelReference: Aerozen G2 Smart Toilet; Manufacturer: American Standard; ProductionYear: 2021
Pset_DistributionFlowElementCommon - Reference: Aerozen G2 Smart Toilet
Constraints - Elevation: 0 mm
Construction - ElectricalConnectorOffsetHorizontal: 330 mm; ElectricalConnectorOffsetVertical: 300 mm; ToiletBowlHole: yes; ToiletLidTop: no
Dimensions - Area: 1.14103 m2; Volume: 0.149242 m3
Identity Data - Mark: 1
Mechanical - System Classification: Power,Sanitary,Domestic Cold Water
Other - AssetIdentifier: n/a; BarCode: Please Record On Commissioning.; Category: Plumbing Fixtures; Family: CEAS5017-0110400T0: Aerozen G2 Smart Toilet; Family and Type: CEAS5017-0110400T0: Aerozen G2 Smart Toilet; InstallationDate: Please Record On Commissioning.; SerialNumber: Please Record On Commissioning.; Type: CEAS5017-0110400T0: Aerozen G2 Smart Toilet; Type Id: CEAS5017-0110400T0: Aerozen G2 Smart Toilet; WarrantyStartDate: Please Record On Commissioning.
Phasing - Phase Created: New Construction
Constraints(Type) - Default Elevation: 0 mm
Data(Type) - ConnectionSize: n/a; FlowRate: 6L litre per flush; InstallationType: Floor Mounted; ProductCategory: Shower Toilets (30); ProductGroup: Shower Toilet (01); ProductWeight: 67 kg; StyleSegment: Modern; SubCategory: Shower Toilet Systems & Seats (31)
Identity Data(Type) - Assembly Code: C1030200; Description: Aerozen G2 Smart Toilet; Keynote: N13; Manufacturer: American Standard; Model: Aerozen G2 Smart Toilet; OmniClass Number: 23.45.05.14.14; OmniClass Title: Sinks/Lavatories; Type Comments: CEAS5017-0110400T0; Type Name: Aerozen G2 Smart Toilet; URL: https://www.americanstandard-apac.com/
Model Properties(Type) - _Author: AM; _AuthorizedBy: bimstore; _BimSpecGuid: 0; _BSBibleVersion: 16; _CreatedBy: https://www.bimstore.co; _CurrentRevision: 1; _DistributedBy: https://www.bimstore.co; _ObjectUserGuide: https://www.bimstore.co/products/ceas5017-0110400t0/document/object-user-guide; BIMObjectName: AmericanStandard_ShowerToilet_Aerozen_(CEAS5017-0110400T0); NBSDescription: n/a; NBSNote: n/a; NBSObjectName: American Standard - n/a; NBSOfficeMasterTag: n/a; NBSReference: n/a
Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; ClassificationName: Uniclass2015; ClassificationValue: Pr_40_20_87_89; CodePerformance: n/a; Color: White Heat II; Constituents: n/a; CreatedBy: https://www.americanstandard-apac.com/; CreatedOn: 2021-03-01T09:00:00; DocumentationCertificates: https://www.bimstore.co/products/ceas5017-0110400t0/document/product-certificates; DocumentationInstallationGuide: https://www.bimstore.co/products/ceas5017-0110400t0/document/installation-guide; DocumentationLiterature: https://www.bimstore.co/products/ceas5017-0110400t0/document/product-literature; DocumentationMaintenance: https://www.bimstore.co/products/ceas5017-0110400t0/document/maintenance-information; DocumentationTechnical: https://www.bimstore.co/products/ceas5017-0110400t0/document/technical-data-sheet; DurationUnit: Years; ExpectedLife: 0; Family Name: CEAS5017-0110400T0; Features: n/a; Finish: n/a; Grade: n/a; ManufacturerName: American Standard; Material: PP;Vitreous China;Plastic; ModelNumber: CEAS5017-0110400T0; ModelReference: Aerozen G2 Smart Toilet; ProductionYear: 2021; ReferencedStandard: SNI 03-0797-2006;PNS 156:2000;PNS 993:2000; ReplacementCost: n/a; Shape: n/a; Size: L 791*W453*H565 mm; TypeName: Aerozen G2 Smart Toilet; WarrantyDescription: n/a; WarrantyDurationLabor: 0; WarrantyDurationParts: 0; WarrantyDurationUnit: Years; WarrantyGuarantorLabor: https://www.americanstandard-apac.com/; WarrantyGuarantorParts: https://www.americanstandard-apac.com/
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
